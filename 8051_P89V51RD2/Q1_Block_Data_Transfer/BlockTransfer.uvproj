# Keil uVision project BlockTransfer.uvproj, settings and files
target P89V51RD2 (MCS-51)
  device: P89V51RD2 NXP (Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(11059200)
  output: BlockTransfer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 block_transfer.asm
